# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtt_inc +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\..\Libraries\stm32f10x_Libraries;..\..\..\Libraries\stm32f10x_Libraries\STM32F10x_StdPeriph_Driver\inc;applications;drivers;..\..\..\Libraries\myLib\bsp;..\..\..\Libraries\myLib\adc;..\..\..\Libraries\myLib\eeprom;..\..\..\Libraries\myLib\flash;..\..\..\Libraries\myLib\lcd;..\..\..\Libraries\myLib\LedDriver;..\..\..\Libraries\myLib\Logic;..\..\..\Libraries\myLib\motion;..\..\..\Libraries\myLib\peripherals;..\..\..\Libraries\myLib\rtc;..\..\..\Libraries\myLib\sensor;..\..\..\Libraries\myLib\math;..\..\..\Libraries\myLib\dido;..\..\myFinsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c
    ./applications/: startup.c
  group Drivers
    drivers/: board.c stm32f10x_it.c usart.c
  group STM32_StdPeriph
    ../../../Libraries/stm32f10x_Libraries/: system_stm32f10x.c startup_stm32f10x_hd.s
    ../../../Libraries/stm32f10x_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../src/: components.c
  group bsp
    drivers/: led.c
    ../../../Libraries/myLib/bsp/: delay.c sys.c
    ../../../Libraries/myLib/math/: crc.c
  group peripherals
    ../../../Libraries/myLib/peripherals/: mcu_exit.c mcu_gpio.c mcu_softi2c.c mcu_softspi.c mcu_spi.c mcu_wdg.c
  group cmd_finsh
    ../../myFinsh/: finsh_adc.c finsh_app.c finsh_eeprom.c finsh_flash.c finsh_l6480.c finsh_logic.c finsh_motor.c finsh_rgb_sensor.c finsh_temp_sensor.c finsh_exit.c finsh_display.c
  group adc
    ../../../Libraries/myLib/adc/: mcp3421.c
  group logic
    ../../../Libraries/myLib/Logic/: 74HC165.c 74HC595.c
  group flash
    ../../../Libraries/myLib/flash/: w25qxx.c
  group sensor
    ../../../Libraries/myLib/sensor/: isl29125.c ds18b20.c
  group stepMotor
    ../../../Libraries/myLib/motion/: L6480.c
  group display
    ../../../Libraries/myLib/lcd/: TextLCD.c
    ../../../Libraries/myLib/LedDriver/: TM1638.c
  group dido
    ../../../Libraries/myLib/dido/: dido.c
  group eeprom
    ../../../Libraries/myLib/eeprom/: at24cxx.c
